Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 84978118-f97b-49ed-8c98-c9f945e1f034, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-21T00:51:37+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12179880_IB_G5110_ED:21511008_IB_12179880_G5110_ED, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, Polypropylene, z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 598 mm; Height: 845 mm; Depth: 600 mm
Classification: E1030.80 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 21511008_IB_12179880_G5110_ED; sets with these values: 2

# IfcDistributionPort, Port_357890_1
Description: Flow; FlowDirection: SOURCEANDSINK
